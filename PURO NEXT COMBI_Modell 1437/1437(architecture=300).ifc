Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_47/temp/tmp_2780_87_98ZRK/format_1/1437(architecture=300).ifc
Time: 2025-08-11T06:11:50
Made in: PARTsolutions

# IfcProject, 1437(architecture=300)
Description: PURO NEXT COMBI

# IfcDiscreteAccessory, 1437(architecture=300)
In: BUILDING
Description: 1437(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 1437
ePset_PARTsolutions - NB: 1437(architecture=300); NN: 1437; NT: PURO NEXT COMBI; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 1437(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 1437; B: 1437.png; C: PURO NEXT COMBI; E: KALDEWEI; EF000049: 1900; EF004567: 900
